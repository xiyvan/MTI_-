# Keil uVision project project1.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project1 +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM,__FPU_USED = 1
  c include: ..\MDK-ARM;..\CMSIS;..\Drivers\inc;..\BSP;..\Alhorithm;..\RTOS\include;..\RTOS\portable\RVDS\ARM_CM4F;..\RTOS;..\APP;..\exti_driver;D:\keil 5\ARM\CMSIS-DSP\1.14.2\Include;..\leg_solve
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
    ../RTOS/: make_task.c
  group Drivers
    ../Drivers/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_tim.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_spi.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_can.c stm32f4xx_i2c.c
  group Setup
    ../CMSIS/: startup_stm32f40_41xxx.s
  group APP
    ../APP/: LED_Blink_task.c BUZZER_task.c SERVOS_task.c CHASSIS_task.c REMOTE_task.c
  group BSP
    ../BSP/: BSP_LED.c BSP_Delay.c BSP_Usart.c BSP_Tim.c BSP_pwm.c BSP_CAN.c BSP_motor.c
  group Algorithm
    ../Alhorithm/: PID.c Z_math.c arm_cortexM4lf_math.lib
  group RTOS
    ../RTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group RTOS_me
    ../RTOS/portable/MemMang/: heap_4.c
    ../RTOS/portable/RVDS/ARM_CM4F/: port.c
  group exti_driver
    ../exti_driver/: RM_motor.c
